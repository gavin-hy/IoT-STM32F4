# Keil uVision project Iot-Mdk.uvprojx, settings and files
target Iot-DemoAPP (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Iot-Mdk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Startup\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Startup\CMSIS\Include;..\sources;..\Drivers\BSP\LED;..\Drivers\BSP\BEEP;..\Drivers\BSP\KEY;..\Middleware\FreeRTOS\inc;..\Drivers\BSP\USART;..\Middleware\easylogger\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Sources
    ../sources/: main.c stm32f4xx_it.c
    ../Startup/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Startup/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h
  group Startup
    ../Startup/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/bsp
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/BEEP/: beep.c
    ../Drivers/BSP/USART/: usart.c
  group Drivers/hal
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usart.c
  group Middleware/freertos
    ../Middleware/FreeRTOS/src/: croutine.c heap_4.c list.c port.c queue.c tasks.c timers.c
  group Middleware/easylog
    ../Middleware/easylogger/src/: elog.c elog_utils.c
    ../Middleware/easylogger/port/: elog_port.c
